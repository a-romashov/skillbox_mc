# Keil uVision project part4.uvprojx, settings and files
target f103c8t6 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: part4
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./: main.c
    ../blinker/: blinker.c
    ./setup/: setup.c
software components: CMSIS:CORE 6.1.0, Device:GPIO 1.3, Device:Startup 1.0.0
